# Keil uVision project STM32_RTOS.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_RTOS
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\firmware\inc;..\firmware\inc;..\FreeRTOS\include;..\..\SOURCE;..\FreeRTOS\portable\GCC\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../firmware/src/: cds.c exti.c fnd.c key.c led.c main.c uart.c
    ./: freeRTOS_test.c
  group RTOS_kernel
    ../FreeRTOS/Source/: list.c queue.c tasks.c
  group RTOS_pots
    ../FreeRTOS/portable/MemMang/: heap_1.c
    ../FreeRTOS/portable/GCC/ARM_CM3/: port.c
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
